SUMMARY = "Blackbird provisioning for Greengrass v2"
DESCRIPTION = ""
LICENSE = "CLOSED"

DEPENDS = "greengrass"

# TODO: Compile and install trusted "FleetProvisioningByClaim.jar" from 'bb-provision/java'
